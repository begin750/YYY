# Keil uVision project Rain.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT87F52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(24000000)
  output: Rain +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Output
  group 源组 1
    ./: STARTUP.A51
  group C51.1
    ./C51.1/: main.c
  group C51.2
    ./C51.2/: send.c
  group C51.3
    ./C51.3/: iic.c
